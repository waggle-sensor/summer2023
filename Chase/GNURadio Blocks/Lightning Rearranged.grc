options:
  parameters:
    generate_options: qt_gui
    id: LightningSeperator
    output_language: python
    title: LightningSeperator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: Open
    type: byte
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-60'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '.01'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '.01'
    offset: '0'
    phase: '3'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: '100'
    offset: '0'
    phase: '3'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_and_xx_0
  id: blocks_and_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '10000000'
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '1000'
    type: byte
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '10000000'
    type: complex
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_or_xx_0
  id: blocks_or_xx
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_peak_detector2_fb_0
  id: blocks_peak_detector2_fb
  parameters:
    alpha: '0.001'
    look_ahead: '1000'
    threshold_factor_rise: '1'
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '.021'
    init: '0'
    low: '.021'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: /media/waggle/Seagate Por/Data/Filtered/Filtered0
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/waggle/Seagate Por/Data/baseband_-357143Hz_11-06-43_09-06-2023.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/waggle/Desktop/SDR/baseband_111059183Hz_14-42-57_06-06-2023.wav
    repeat: 'True'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Binary Gate',   # will show up in GRC
                  in_sig=[np.float32,np.byte],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              if (np.all(input_items[1] == 1)):
                      output_items[0][:] = input_items[0][:]
              else:
                      output_items[0][:] = 0
              return len(output_items[0])
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Binary Gate',   # will show up in GRC
                  in_sig=[np.float32,np.byte],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              if (np.all(input_items[1] == 1)):
                      output_items[0][:] = input_items[0][:]
              else:
                      output_items[0][:] = 0
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Binary Gate',   # will show up in GRC
                  in_sig=[np.float32,np.byte],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              if (np.all(input_items[1] == 1)):
                      output_items[0][:] = input_items[0][:]
              else:
                      output_items[0][:] = 0
              return len(output_items[0])
  states: {state: disabled}
- name: epy_block_0_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Binary Gate',   # will show up in GRC
                  in_sig=[np.complex64,np.byte],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              if (np.all(input_items[1] == 1)):
                      output_items[0][:] = input_items[0][:]
              else:
                      output_items[0][:] = 0
              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each example_param this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, stall=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Stall Gate',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.stall = stall
              self.toggle = 0
              self.clock = 0



          def work(self, input_items, output_items):
              if (self.toggle == 0):
                      if (np.any(input_items[0] == 1)):
                              self.toggle = 1
                              output_items[0][:] = 1
                      else:
                              output_items[0][:] = 0
              if (self.toggle == 1):
                      output_items[0][:] = 1
                      self.clock = self.clock+1
                      print (self.clock)
                      if (self.clock >= self.stall):
                              self.toggle = 0
                              self.clock = 0
                              output_items[0][:] = 0
              return len(output_items[0])
    stall: '2500'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each example_param this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, stall=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Stall Gate',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.stall = stall
              self.toggle = 0
              self.clock = 0



          def work(self, input_items, output_items):
              if (self.toggle == 0):
                      if (np.any(input_items[0] == 1)):
                              self.toggle = 1
                              output_items[0][:] = 1
                      else:
                              output_items[0][:] = 0
              if (self.toggle == 1):
                      output_items[0][:] = 1
                      self.clock = self.clock+1
                      if (self.clock >= self.stall):
                              self.toggle = 0
                              self.clock = 0
                              output_items[0][:] = 0
              return len(output_items[0])
    stall: '500'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Raw
    label2: Filtered Data
    nconnections: '2'
    size: '2000'
    srate: samp_rate
    type: float
    ymax: '.02'
    ymin: '-.02'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ZAP
    name: '"Lightning"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: KABOOM
    yunit: '"dB"'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_or_xx_0, '1']
- [analog_pwr_squelch_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_and_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_and_xx_0, '1']
- [analog_sig_source_x_0_0_0_0, '0', blocks_add_xx_1, '1']
- [blocks_add_xx_1, '0', blocks_threshold_ff_0, '0']
- [blocks_and_xx_0, '0', blocks_or_xx_0, '0']
- [blocks_char_to_float_1, '0', epy_block_0_1, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_delay_0, '0', epy_block_0, '0']
- [blocks_delay_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_delay_1, '0', epy_block_0_2, '0']
- [blocks_float_to_char_0, '0', epy_block_1, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_or_xx_0, '0', epy_block_0_0, '1']
- [blocks_peak_detector2_fb_0, '0', blocks_delay_0_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_1_0, '0']
- [blocks_throttle_0, '0', blocks_add_xx_1, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0, '0', blocks_delay_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_wavfile_source_0_0, '0', epy_block_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_0_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_0_1, '0', blocks_float_to_char_1, '0']
- [epy_block_0_2, '0', analog_pwr_squelch_xx_0, '0']
- [epy_block_1, '0', epy_block_0, '1']
- [epy_block_1, '0', epy_block_0_2, '1']
- [epy_block_1_0, '0', blocks_float_to_char_0, '0']

metadata:
  file_format: 1
